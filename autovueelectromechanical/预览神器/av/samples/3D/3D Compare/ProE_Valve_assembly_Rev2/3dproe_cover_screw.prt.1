# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 3.0 (F000) (file 3dproe_cover_screw.prt.1)

Parameters:
  DESCRIPTION = "STEEL SCREW"
  MODELED_BY = "L. CONARD"
  PTC_COMMON_NAME = "STEEL SCREW"