# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 3.0 (F000) (file 3dproe_stem.prt.1)

Parameters:
  DESCRIPTION = "BRASS STEM"
  MODELED_BY = "L. CONARD"
  PTC_COMMON_NAME = "BRASS STEM"