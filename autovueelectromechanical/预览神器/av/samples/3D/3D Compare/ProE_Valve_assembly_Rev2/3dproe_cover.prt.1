# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 3.0 (F000) (file 3dproe_cover.prt.1)

Parameters:
  DESCRIPTION = "BRASS HANDLE"
  MODELED_BY = "L. CONARD"
  PTC_COMMON_NAME = "BRASS HANDLE"